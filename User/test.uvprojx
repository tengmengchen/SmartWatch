# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: fromelf --bin --output ./Objects/test.bin ./Objects/test.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c misc: --no-multibyte-chars
  c include: D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Core\Inc;.\User;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\System;.\BSP\Inc;.\Middlewares\LVGL\GUI;.\Middlewares\LVGL\GUI\lvgl;.\Middlewares\LVGL\GUI\lvgl\src;.\Middlewares\LVGL\GUI\lvgl\examples\porting;.\BSP\Inc\LCD;.\Middlewares\LVGL\GUI_APP\demos;.\Middlewares\LVGL\GUI_APP\demos\stress;.\Middlewares\LVGL\GUI_APP\demos\widgets;.\Middlewares\LVGL\GUI\porting;.\Middlewares\LVGL\GUI_APP\FUNC\inc;.\Middlewares\LVGL\GUI_APP\GUI_APP\inc;.\Middlewares\LVGL\GUI_APP\ICON;.\Middlewares\LVGL\GUI_APP;.\User\Tasks\include
  memory RVCT4: ROM 0x8000000 size 0x73fff
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: main.c
    ./Core/Inc/: FreeRTOSConfig.h
  group FreeRTOS/Src
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Core
    ./Core/Src/: stm32f4xx_it.c Usart.c i2c.c spi.c tim.c dma.c RTC.c
  group Driver/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c
  group system
    ./System/: delay.c printf.c
  group BSP/Src
    ./BSP/Src/: BL24C02.c WDG.c AHT21.c Sensor.c SPL06.c CST816.c EM7028.c MPU6050.c BLE.c LSM303.c KEY.c
    ./BSP/Src/LCD/: lcd.c lcd_init.c
  group Middlewares/lvgl/example/porting
    ./Middlewares/LVGL/GUI/porting/: lv_port_disp.c lv_port_indev.c
  group Middlewares/lvgl/src/core
    ./Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ./Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Middlewares/lvgl/src/extra
    ./Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ./Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group Middlewares/lvgl/src/font
    ./Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./Middlewares/LVGL/GUI_APP/ICON/src/: yuanguheiti_iconfont18.c
  group Middlewares/lvgl/src/gpu
    ./Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./Middlewares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middlewares/lvgl/src/hal
    ./Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ./Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/lvgl_app
    ./Middlewares/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ./Middlewares/LVGL/GUI_APP/demos/widgets/: lv_demo_widgets.c
    ./Middlewares/LVGL/GUI_APP/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ./Middlewares/LVGL/GUI_APP/FUNC/src/: PageChange.c Computer.c HWDataAccess.c
    ./Middlewares/LVGL/GUI_APP/GUI_APP/src/: ComputerPage.c HomePage.c MenuPage.c CalendarPage.c
    ./Middlewares/LVGL/GUI_APP/ICON/src/: Temperature .c ui_font_Cuyuan18.c ui_font_Cuyuan20.c ui_font_Cuyuan24.c ui_font_Cuyuan30.c ui_font_Cuyuan38.c ui_font_Cuyuan48.c ui_font_Cuyuan80.c ui_font_Cuyuan100.c ui_font_iconfont16.c ui_font_iconfont24.c ui_font_iconfont28.c ui_font_iconfont30.c ui_font_iconfont32.c ui_font_iconfont34.c ui_font_iconfont45.c
  group User/Tasks
    ./User/Tasks/: AHT21_task.c LVGL_task.c SPL06_task.c watchtask.c WDG_task.c
software components: Device:Startup 2.6.3
